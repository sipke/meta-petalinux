
# Fix GNU_HASH
TARGET_CC_ARCH += "${LDFLAGS}"

